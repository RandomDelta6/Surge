File: Surge.kicad_sch (KiCad schematic)
At the start: 18 parts, among them J1 , J2 , SW1 C1005B 10A TCB

Commit message: Update BOM and ReadMe
Parts:
- SW1: value C1005B 10A TCB -> C1005B 15A TCB
